Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SOLAR-G2 30.944.3600.IFC
Time: 2023-11-03T07:32:36
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SOLAR-G2 30.944.3600
In: Default Storey
SolidWorks Custom Properties - Description: PWR(30W);LUM.FLUX(3600lm)
PSet_Mass_Property - Mass Measure: 35.8379; Area Measure: 2.37494 m2; Volume Measure: 0.0358379 m3
